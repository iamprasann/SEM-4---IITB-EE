ORG 0000H
	LJMP START
ORG 000BH
	LJMP HANDLER

ORG 0050H
HANDLER: 
	MOV TH0, R1		;R0, R1 PLACEHOLDERS FOR DIFFERENT FREQUENCIES
	MOV TL0, R0
	CPL P1.4
	RETI
	
ORG 0100H
START: 
	SETB EA
	SETB ET0
	MOV TMOD, #00010001B
	
LOOP:
	MOV R1, #0F2H
	MOV R0, #0B3H
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0F9H
	MOV R0, #059H
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0F7H
	MOV R0, #01FH
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0F6H
	MOV R0, #009H
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0FBH
	MOV R0, #004H
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0F7H
	MOV R0, #01FH
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0FAH
	MOV R0, #068H
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	MOV R1, #0F7H
	MOV R0, #01FH
	
	MOV TH0, R1
	MOV TL0, R0
	SETB TR0
	
	ACALL DELAYHALFS
	
	CLR TR0
	
	LJMP LOOP
	
DELAYHALFS:
	mov r2, #15
	delay50000musec: 
		mov th1, #03ch 
		mov tl1, #0b8h 
		setb tr1 
		del: jnb tf1, del
		clr tr1 
		clr tf1 
		djnz r2, delay50000musec
ret	

END