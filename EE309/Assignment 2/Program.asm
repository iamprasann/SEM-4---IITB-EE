org 100H

MOV AX, 7000H
MOV DS, AX
MOV SI, 00H
MOV DS:SI, 47H
MOV SI, 01H
MOV DS:SI, 79H
MOV SI, 00H
MOV AL, DS:00H
SBB AL, DS:01H
DAS

MOV AH, AL
AND AL, 0FH
AND AH, 0F0H
ROR AH, 4
MOV DS:02H, AH
MOV DS:03H, AL
MOV BH, AH
MOV BL, AL
MUL BH
MOV DL, AL
AAM

MOV DS:04H, AH
MOV DS:05H, AL
MOV BH, 7
MOV AL, DL
MOV AH, 00H
DIV BH
MOV DS:04H, AH
MOV DS:05H, AL

RET